# Keil uVision project PMsen.uvprojx, settings and files
target LoRaMultiSen (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaMultiSen +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L072xx,USE_B_L072Z_LRWAN1,USE_HAL_DRIVER, REGION_EU868
  c misc: --C99
  c include: ..\..\Drivers\BSP\MLM32L07X01;..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\Third_Party\Lora\Core;..\..\Middlewares\Third_Party\Lora\Crypto;..\..\Middlewares\Third_Party\Lora\Mac;..\..\Middlewares\Third_Party\Lora\Phy;..\..\Middlewares\Third_Party\Lora\Utilities;..\..\Drivers\BSP\Components\Common;..\..\Drivers\BSP\Components\hts221;..\..\Drivers\BSP\Components\lps22hb;..\..\Drivers\BSP\Components\lps25hb;..\..\Drivers\BSP\Components\sx1276;..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\Middlewares\Third_Party\Lora\Mac\region;.\inc;..\..\sensors
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc/Setup
    ./inc/: config.h Commissioning.h
  group Drivers
    ../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ./: config.h
  group L0HAL
    ../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c
  group Project/Startup
    ./: startup_stm32l072xx.s
  group LoRa/Core
    ../../Middlewares/Third_Party/Lora/Core/: lora.c lora-test.c
  group LoRa/MAC
    ../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group LoRa/MAC/Reg
    ../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group LoRa/Util
    ../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
  group LoRa/Crypto
    ../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group APP/LoRaDunchy
    ./src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Sensors
    ../../Sensors/: HPM.c sensors.c SI7013.c
